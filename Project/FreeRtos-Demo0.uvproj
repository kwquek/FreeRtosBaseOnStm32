# Keil uVision project FreeRtos-Demo0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeRtos-Demo0 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,  STM32F10X_HD
  c include: ..\source\CMSIS;..\source\FreeRtos;..\source\FreeRtos\include;..\source\STM32F10x_StdPeriph_Driver\inc;..\source\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../source/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group ST_LIB
    ../source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group FreeRtos
    ../source/FreeRtos/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group user
    ../source/user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
